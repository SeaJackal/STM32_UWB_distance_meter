# Keil uVision project stm32f103c8t6_uwb.uvprojx, settings and files
target stm32f103c8t6_uwb (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: stm32f103c8t6_uwb +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Hardware/DW1000;../Hardware/DW1000/decadriver;../Hardware/DW1000/platform;../UWB_Lib/Inc;../Libs
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../UWB_Lib/Inc/: uwb_boat_interface.h uwb_simple_distance_meter.h uwb_ui.h
    ../UWB_Lib/Src/: uwb_ui.c uwb_distance_meter.c uwb_boat_interface.c
    ../Libs/: free_index_controller.c moving_average.c uart_port_plotter_interface.c crc.h crc.c
    ../Hardware/DW1000/: dw1000.c
    ../Hardware/DW1000/decadriver/: deca_device.c deca_params_init.c
    ../Hardware/DW1000/platform/: deca_mutex.c deca_sleep.c deca_spi.c
    ../examples/ex_03a_tx_wait_resp/: tx_wait_resp_example.c
    ../Src/: main.c gpio.c spi.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
software components: CMSIS:CORE 5.5.0, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDOUT 1.2.0
